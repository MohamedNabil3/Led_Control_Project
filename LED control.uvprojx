# Keil uVision project LED control.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED control
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Project_Files\MCAL\INT;.\Project_Files\APP;.\Project_Files\Config;.\Project_Files\MCAL\DIO;.\Project_Files\HAL\LED;.\Project_Files\MCAL\SisTick;.\Project_Files\HAL\SW1;.\Project_Files\HAL\SW2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group MCAL
    ./Project_Files/MCAL/INT/: INT_CTRL.c
    ./Project_Files/MCAL/DIO/: GPIO.c
    ./Project_Files/MCAL/SisTick/: SisTick.c
  group APP
    ./: main.c
  group CONFIG
    ./Project_Files/Config/: INT_CONFIG.c
  group HAL
    ./Project_Files/HAL/LED/: LED0.c
    ./Project_Files/HAL/SW1/: SW1.c
    ./Project_Files/HAL/SW2/: SW2.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
